# Keil uVision project tc6014.uvproj, settings and files
target tc6014 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: v1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\app;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\CMSIS;.\lib\tc6014\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./app/: init.c main.c stm32f10x_it.c system_stm32f10x.c
  group tc6014
    ./lib/tc6014/src/: tc6014.c
  group LIB
    ./lib/CMSIS/startup/: startup_stm32f10x_hd.s
    ./lib/CMSIS/: core_cm3.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ./: readme.txt
